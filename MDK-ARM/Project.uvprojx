# Keil uVision project Project.uvprojx, settings and files
target Project (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: PY32F002Bx5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.2
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00006000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,PY32F002Bx5
  c misc: --diag_suppress=177,550
  c include: ..\Src;..\HAL_Driver\Src;..\HAL_Driver\Inc;..\User\Src;..\User\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Core
    ../EWARM/: py32f002bxx_Start_Kit.c system_py32f002b.c
    ./: startup_py32f002bxx.s
  group Drivers
    ../HAL_Driver/Src/: py32f002b_hal.c py32f002b_hal_rcc.c py32f002b_hal_rcc_ex.c py32f002b_hal_gpio.c py32f002b_hal_pwr.c py32f002b_hal_uart.c py32f002b_hal_cortex.c py32f002b_hal_adc.c py32f002b_hal_tim.c py32f002b_hal_tim_ex.c py32f002b_hal_i2c.c py32f002b_hal_iwdg.c py32f002b_hal_flash.c py32f002b_it.c py32f002b_hal_msp.c py32f002b_hal_spi.c
  group Src
    ../User/Src/: adjust.c arithmetic.c flash.c iwdg.c led.c main.c sys.c tim.c usart.c 1002.c I2C.c app_usart.c voice_app.c baseline_tracking.c sc7a20.c sleep.c mh1612s.c rfid.c
  group Inc
    ../User/Inc/: adjust.h arithmetic.h flash.h iwdg.h led.h main.h sys.h tim.h usart.h 1002.h app_usart.h
  group Protocol
    ../User/Src/protocol/: card_emu.c picc.c iso14443a.c iso14443b.c intc.c
  group NFC
    ../User/Src/nfc/: nfc_app.c nfc_config.c nfc_transfer.c
software components: CMSIS:CORE 5.3.0
